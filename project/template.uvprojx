# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IROM(0x08000000,0x040000) IRAM(0x20000000,0x0C000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\CMSIS;..\Library\Include;..\User;..\hardware\uart;..\hardware\delay;..\Freertos\include;..\Freertos\portable\RVDS\ARM_CM4F;..\hardware\adc;..\hardware\timer;..\hardware\gpio;..\hardware\gd_iic;..\hardware\MLX90614;..\Bia;..\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Bia
    ../Bia/: gd32f303c_bia.c readme.txt
  group User
    ../User/: main.c systick.c gd32f30x_it.c
  group CMSIS
    ../CMSIS/: system_gd32f30x.c
  group Library
    ../Library/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../Startup/: startup_gd32f30x_xd.s
  group hardware
    ../hardware/uart/: uart.c
    ../hardware/delay/: delay.c
    ../hardware/adc/: adc.c
    ../hardware/timer/: timer.c
    ../hardware/gpio/: gpio.c
    ../hardware/gd_iic/: gd_i2c.c
    ../hardware/MLX90614/: mlx90614.c
  group Freertos
    ../Freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Freertos_PORTABLE
    ../Freertos/portable/MemMang/: heap_4.c
    ../Freertos/portable/RVDS/ARM_CM4F/: port.c
